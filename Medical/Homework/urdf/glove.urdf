Commit message: Updating Homework

File: Medical/Homework/urdf/glove.urdf (robot description, URDF)
Before this commit: robot hand_3r_glove, 15 links, 14 joints
Links:
- added link world
Joints:
- added joint world_to_palm: type fixed, parent world, child palm_link, origin xyz=0 0 0 rpy=0 0 0
